<?xml version="1.0" encoding="UTF-8"?>
<workspace>
<project>
<path>$WS_DIR$\dual_threadx_core1.ewp</path>
</project>
<batchBuild />
</workspace>